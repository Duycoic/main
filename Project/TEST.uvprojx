# Keil uVision project TEST.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.15.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEST
  c flags: Optim=1 OneElfS=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F407xx,USE_HAL_DRIVER
  c include: ..\User;..\..\STM32F407ZGT6_TEST;..\Drivers;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\Drivers\CMSIS\Device\ST\STM32F4xx\Source\Templates;..\Drivers\STM32F4xx_HAL_Driver\Inc;..\Middlewares;..\APP;..\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/: main.c main.h stm32f4xx_it.c stm32f4xx_it.h stm32f4xx_hal_conf.h system_stm32f4xx.c stm32f4xx_hal_msp.c sys.c sys.h Delay.c Delay.h EXTI.c EXTI.h UART.c UART.h TIM.c TIM.h SPI.c SPI.h
  group Drivers
    ../Drivers/CMSIS/Device/ST/STM32F4xx/Source/: startup_stm32f407xx.s
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_exti.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c
  group BSP
    ../BSP/: LED.c LED.h KEY.c KEY.h W25Q64.c W25Q64.h
  group Middlerware
    ../Middlewares/: ringbuf.c ringbuf.h
